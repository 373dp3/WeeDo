# Repository 373dp3/WeeDo

File README.md:

# WeeDo
Sakura.ioとGoogleスプレッドシートを用いたビジネス向けIoTを実現する為の各種ソフトウェアです。
可能な限りオープンソース（MITライセンス）にてご提供しております。

## 概要図

同一フロア内の機器から取得したデータを近距離無線モジュールTWE-Liteで親機に送信。
4G LTE通信モジュールSakura.ioとArduinoの組み合わせで情報を中継・転送を行いGoogleスプレッドシートに
値を挿入するためのソフトウェア群です。

## 特徴
1. 超・低コスト志向 (月60円のLTE回線を数十台の無線センサ子機で共有、親機OSレス)
2. 表計算ソフトの知識でフロントエンドを構成する。
3. 商用向け転用に利用しやすいMITライセンス

## 活用例
1. RFIDリーダを用いたプレゼンス管理
2. 工場の可動率管理（サイクルタイムモニタ）
3. 試験装置の稼働終了メール通知装置
4. 環境温度の定点観測装置

等など、ビジネス向けIoTシステムを月額ワンコイン以下の通信費で維持。
Googleスプレッドシートを用いますので表示内容をご自身で簡単にカスタマイズする事ができます。

## フォルダ構成
<table>
  <tr>
    <td>DownloadWdLog </td>
    <td>Googleスプレッドシートに追記したログを一括取得してCSVファイルに保存する為のツール </td>
  </tr>
  <tr>
    <td>bin </td>
    <td>各種インストーラ、コンパイル済みバイナリ </td>
  </tr>
  <tr>
    <td>bin </td>
    <td>Googleスプレッドシートに追記したログを一括取得してCSVファイルに保存する為のツール </td>
  </tr>
  <tr>
    <td>common </td>
    <td>parent, seed70mm_frid_client, simple_raw_clientから参照している共通コード </td>
  </tr>
  <tr>
    <td>eagle </td>
    <td>電子回路CAD EAGLE用の各種ファイル </td>
  </tr>
  <tr>
    <td>parent </td>
    <td>親機のArduino向けソースコード </td>
  </tr>
  <tr>
    <td>seed70mm_rfid_client </td>
    <td>seeedstudioで販売している70mm RFIDと接続するArduino向けソースコード </td>
  </tr>
  <tr>
    <td>simple_raw_client </td>
    <td>TWE-LiteのRAW用ファームウェアと組み合わせて使用する為のArduino向けソースコード </td>
  </tr>
  <tr>
    <td>twe-lite </td>
    <td>2.4GHz無線モジュールTWE-Lite向けソースコード </td>
  </tr>
</table>
(VPSサーバにてGoogleスプレッドシートに値を挿入する処理については公開準備中です)

## 公式サイト
<a href="https://secure.dp3.jp/WeeDo/">https://secure.dp3.jp/WeeDo/</a>

## EAGLE design eagle/Parent/SignalTower/ssChildSignalTower.brd

Parts:
DI1: AMON0.5SQ_WIRE_HOLE
POW: AMON0.5SQ_WIRE_HOLE
PT1, PT2: PS1101W; GL-01674-PS1101W-PHOTO-TRANSISTOR
R1, R2: 1M; R0603
SV7: FE05-1
U$1: LITE

Connections:
+3V3: POW.1, U$1.P$5 (5.VCC)
+UB: R1.1, R2.2
A1: DI1.1, PT1.C, R1.2, U$1.P$13 (13.DI1), U$1.P$23 (23.AI1)
A2: PT2.C, R2.1, U$1.P$15 (15.DI2), U$1.P$24 (24.AI2)
A3: U$1.P$16 (16.DI3), U$1.P$22 (22.AI3)
A4: U$1.P$18 (18.DI4), U$1.P$25 (25.AI4)
DO1: U$1.P$3 (3DO1)
DO2: U$1.P$4 (4DO2)
GND: DI1.2, POW.2, PT1.E, PT2.E, SV7.5, U$1.P$20 (20.GND), U$1.P$28 (28.GND)
SCL: U$1.P$14 (14.SCL)
SDA: U$1.P$17 (17.SDA)
TWE.PRG: SV7.3, U$1.P$2 (2.PWM3)
TWE.RST: SV7.1, U$1.P$21 (21.RST)
TWE.RX: SV7.2, U$1.P$9 (9.RX)
TWE.TX: SV7.4, U$1.P$8 (8.TX)

Board: 2 copper layers, 19.9 x 19.9 mm, 8 parts (4 on the bottom side), 11 nets.

## EAGLE design eagle/Parent/SakuraIoBoard/SakuraIo.brd

Parts:
C1, C2: CPOL-EUE2,5-6E; E2,5-6E
C3, C4: C-EUC0603; C0603
IC6: AZ11117D_3REG; TO252
R1: 1k; 0204/7
R2: 1k; R0603
R3: 2k; R0603
R4: 2k; 0204/7
SV1: SAKURA-HRS-CONNECTOR50
SV4: PINHEADER_5_2.54MM
SV7: PINHEADER_4_2.54MM

Connections:
+3.9V: C1.+, C3.1, C4.1, IC6.2 (VOUT), R1.2, R2.1, SV1.P$44.VIN (44.VIN), SV1.P$45.VIN (45.VIN), SV1.P$46.VIN (46.VIN), SV1.P$47.VIN (47.VIN), SV1.P$48.VIN (48.VIN), SV7.3
+UB: C2.+, IC6.3 (VIN), SV4.1
GND: C1.-, C2.-, C3.2, C4.2, R3.2, R4.1, SV1.P$1.GND (1.GND), SV1.P$4.GND (4.GND), SV1.P$7.GND (7.GND), SV1.P$12.GND (12.GND), SV1.P$15.GND (15.GND), SV1.P$19.GND (19.GND), SV1.P$25.GND (25.GND), SV1.P$26.GND (26.GND), SV1.P$32.GND (32.GND), SV1.P$38.GND (38.GND), SV1.P$39.GND (39.GND), SV1.P$40.GND (40.GND), SV1.P$41.GND (41.GND), SV1.P$42.GND (42.GND), SV1.P$50.GND (50.GND), SV4.2, SV7.4
unnamed: IC6.1 (GND), R1.1, R2.2, R3.1, R4.2
SAKURA_LED: SV1.P$20.LED (20.LED), SV7.2
SAKURA_RESET: SV1.P$24.RESET (24.RESET), SV7.1
SAKURA_WAKEIN: SV1.P$22.WAKEIN (22.WAKEIN), SV4.5
SCL: SV1.P$6.SCL (6.SCL), SV4.3
SDA: SV1.P$5.SDA (5.SDA), SV4.4

Notes on the sheet:
HRS H11910CT-ND

Board: 2 copper layers, 50.0 x 13.3 mm, 12 parts (5 on the bottom side), 9 nets.

## EAGLE design eagle/Parent/Arduino/WdParent.brd

Parts:
C4, C7: 0.1uF; C0603
C5, C6: 4.7uF; C0603
C9, C10: C-EU025-025X050; C025-025X050
C11, C12: C-EUC0603; C0603
IC1: AP7333; SOT23
IC8: 23K256-I/P; DIL8
JP1, JP2: JP1E; JP1
LED1, LED2: LEDCHIPLED_0603; CHIPLED_0603
Q1: XTAL/S; QS
R1, R12: 330; R0603
R4, R5, R8: 10k; R0603
R10, R11: 100k; R0603
SV1: MA05-2
SV2: FE05-1
SV4: PINHEADER_5_2.54MM
SV5: C-01604_2.1MMJACK; 2.1MMJACK_SLIM
SV7: PINHEADER_4_2.54MM
SW1: TACT_SWITCH
U1: ATMEGA328P-AU; QFP80P900X900X120-32N
U$1: LITE

Connections:
5: U1.9 (PD5)
10: U1.14 (PB2)
+3.9V: SV7.3
+3V3: C6.1, IC1.2 (VOUT), IC8.8 (VCC), R4.2, R5.2, R8.2, R10.2, R11.2, SV1.7, U1.4 (VCC_2), U1.6 (VCC), U1.18 (AVCC), U$1.P$5 (5.VCC)
+UB: C5.1, IC1.1 (VIN), SV4.1, SV5.+V (VCC)
A0: U1.23 (PC0)
A1: U1.24 (PC1), U$1.P$13 (13.DI1), U$1.P$23 (23.AI1)
A2: IC8.5 (SI), U1.25 (PC2), U$1.P$15 (15.DI2), U$1.P$24 (24.AI2)
A3: IC8.2 (SO), U1.26 (PC3), U$1.P$16 (16.DI3), U$1.P$22 (22.AI3)
A4: IC8.6 (SCK), U1.19 (ADC6), U$1.P$18 (18.DI4), U$1.P$25 (25.AI4)
A5: U1.22 (ADC7)
ARDUINO_RESET: C7.1, R8.1, SV1.2, SW1.1, SW1.2, U1.29 (PC6)
D6: U1.13 (PB1)
DO1: U$1.P$3 (3DO1)
DO2: U$1.P$4 (4DO2)
DTR: C7.2, SV1.1
GND: C4.2, C5.2, C6.2, C9.1, C10.1, C11.1, C12.1, IC1.3 (GND), IC8.4 (GND), LED1.C, LED2.C, SV1.9, SV1.10, SV2.5, SV4.2, SV5.GND, SV5.NC (S), SV7.4, SW1.3, SW1.4, U1.3 (GND_2), U1.5 (GND_3), U1.21 (GND), U$1.P$20 (20.GND), U$1.P$28 (28.GND)
MISO: SV1.6, U1.16 (PB4)
MOSI: SV1.4, U1.15 (PB3)
unnamed: LED2.A, R1.1
unnamed: IC8.7 (!HOLD), R10.1
unnamed: IC8.3 (!WP), R11.1
unnamed: LED1.A, R12.1
unnamed: C9.2, C11.2, Q1.2, U1.7 (PB6)
unnamed: C10.2, C12.2, Q1.1, U1.8 (PB7)
unnamed: C4.1, U1.20 (AREF)
P2: U1.32 (PD2)
RX: JP1.2, SV1.5, U1.30 (PD0)
SAKURA_LED: R1.2, SV7.2
SAKURA_RESET: SV7.1, U1.1 (PD3)
SAKURA_WAKEIN: SV4.5, U1.10 (PD6)
SCK: SV1.8, U1.17 (PB5)
SCL: R5.1, SV4.3, U1.28 (PC5), U$1.P$14 (14.SCL)
SDA: R4.1, SV4.4, U1.27 (PC4), U$1.P$17 (17.SDA)
SOLAR_DETECT: U1.11 (PD7)
SS: IC8.1 (!CS), U1.2 (PD4)
STATUS_LED: R12.2, U1.12 (PB0)
TWE.PRG: SV2.3, U$1.P$2 (2.PWM3)
TWE.RST: SV2.1, U$1.P$21 (21.RST)
TWE.RX: JP2.1, SV2.2, U$1.P$9 (9.RX)
TWE.TX: JP1.1, SV2.4, U$1.P$8 (8.TX)
TX: JP2.2, SV1.3, U1.31 (PD1)

Notes on the sheet:
P2: Android slave intterupt
AP7333 セラミックコンデンサ1uFでOKのLDO 300mA、ドロップ0.3V
8MHz, 22pF
1608(inch0603)
SPI SRAM or EEPROM

Board: 2 copper layers, 48.8 x 38.8 mm, 30 parts (1 on the bottom side), 32 nets.

## Commit log

2018-01-09 親機共用ロジックの初回コミット
2018-01-09 共通コードの移動
2018-01-09 SeedStudio 70mm RFID用のArduinoクライアント
2018-01-09 TWE-Lite SDK 201408版の原本
2018-01-09 201408版SDKをもとにしたWeeDo向け拡張
2018-01-09 bin更新とコメントの修正
2018-01-09 説明用画像の追加
2018-01-09 Create README.md
    初版README.mdの更新
2018-01-09 Update README.md
    表組み構成
2018-01-09 EAGLE関連ファイルの初版
2018-01-09 子機回路図フォルダ訂正
2018-01-09 Update README.md
    EAGLE向け説明補足
2018-01-09 Update README.md
    活用例追加
2018-01-09 Update README.md
    表示崩れ修正
2018-01-09 Update README.md
    表現の訂正
2018-02-12 CT処理の簡潔化
2018-02-12 VisualStudio用slnファイル追加
2019-02-13 簡素化の取りやめ
